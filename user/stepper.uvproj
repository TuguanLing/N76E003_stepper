# Keil uVision project stepper.uvproj, settings and files
target stepper (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: stepper +hex
  c flags: Optimize=7 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include;..\API;..\Common
  group user
    ./Code/: main.c
  group Common
    ../Common/: Common.c Delay.c
  group Startup
    ../Startup/: STARTUP.A51
  group API
    ../API/: stepper.c key.c
